#include "preference.h"
#include <util/delay.h>
#include "MAX6581_Driver.h"

/************************************************************************/
/* Инициализация интерфейса I2C                                         */
/************************************************************************/
void I2C_INIT(void)
{
	DDRD|=0b00000011;	// SDA - PD1, SCL - PD0 на выход
	
	TWSR&= (0<<TWPS1)|(0<<TWPS0);  // Биты предделителя настроены на 1
	TWBR=0x02;                     // Настраиваем частоту шины на 400 кГц
}

/************************************************************************/
/* Команды интефейса I2C, выставление регистров                         */
/************************************************************************/
uint8_t I2C_COMAND(uint8_t action){
	switch(action){
		case I2C_START:
		case I2C_RESTART:
		TWCR = _BV(TWSTA) | _BV(TWEN) | _BV(TWINT);// Если нужно прерывание | _BV(TWIE);
		break;
		case I2C_STOP:
		TWCR = _BV(TWSTO) | _BV(TWEN) | _BV(TWINT);// | _BV(TWIE);
		break;
		case I2C_TRANSMIT:
		TWCR = _BV(TWEN) | _BV(TWINT);// | _BV(TWIE);
		break;
		case I2C_RECEIVE_ACK:
		TWCR = _BV(TWEN) | _BV(TWINT) | _BV(TWEA);//| _BV(TWIE);
		break;
		case I2C_RECEIVE_NACK:
		TWCR = _BV(TWEN) | _BV(TWINT);// | _BV(TWIE);
		break;
	}
	if(action != I2C_STOP)while (!(TWCR & _BV(TWINT)));
	return (TWSR & 0xF8);
}


/************************************************************************/
/* Чтение одного байта из регистра                                      */
/************************************************************************/
uint8_t READ_ONE_BYTE_REG(uint8_t REG_CMD)
{
	uint8_t data = 0;
	_delay_ms(10);

	I2C_COMAND(I2C_START);                  // формируем сигнал START


	TWDR = WRITE_CMD;                            // Загружаем адрес МС (WRITE)
	if (I2C_COMAND(I2C_TRANSMIT)!=0x20)     // Передаем
	{
		TWDR = REG_CMD;                     // Загружаем адрес регистра, маска на A0-A2
		I2C_COMAND(I2C_TRANSMIT);           // Передаем
		
		I2C_COMAND(I2C_START);              // формируем сигнал START
		
		TWDR = READ_CMD;                    // Загружаем адрес МС (READ)
		I2C_COMAND(I2C_TRANSMIT);           // Передаем
		
		I2C_COMAND(I2C_RECEIVE_NACK);       // Принимаем байт 
		
		data = TWDR;
	}

	_delay_ms(10);
	return (data);
}

/************************************************************************/
/* Чтение двух байт из регистра                                         */
/************************************************************************/
uint16_t READ_TWO_BYTE_REG(uint8_t REG_CMD1,uint8_t REG_CMD2)
{
	uint16_t data=0;
	_delay_ms(10);

	I2C_COMAND(I2C_START);                  // формируем сигнал START

	TWDR = WRITE_CMD;                            // Загружаем адрес МС (WRITE)
	if (I2C_COMAND(I2C_TRANSMIT)!=0x20)     // Передаем
	
	{
		TWDR = REG_CMD1;                     // Загружаем адрес регистра
		I2C_COMAND(I2C_TRANSMIT);           // Передаем
		
		I2C_COMAND(I2C_START);              // формируем сигнал START
		
		TWDR = READ_CMD;                        // Загружаем адрес МС (READ)
		I2C_COMAND(I2C_TRANSMIT);           // Передаем
		
		I2C_COMAND(I2C_RECEIVE_ACK);
		data = TWDR;
		data = data<<8;
		I2C_COMAND(I2C_RECEIVE_NACK);    // Принимаем байт младший
	}
	
	_delay_ms(10);
	
	I2C_COMAND(I2C_START);                  // формируем сигнал START
	
	TWDR = WRITE_CMD;                            // Загружаем адрес МС (WRITE)
	if (I2C_COMAND(I2C_TRANSMIT)!=0x20)     // Передаем
	
	{
		TWDR = REG_CMD2;                     // Загружаем адрес регистра
		I2C_COMAND(I2C_TRANSMIT);           // Передаем
		
		I2C_COMAND(I2C_START);              // формируем сигнал START
		
		TWDR = READ_CMD;                    // Загружаем адрес МС (READ)
		I2C_COMAND(I2C_TRANSMIT);           // Передаем
		
		I2C_COMAND(I2C_RECEIVE_NACK);       // Принимаем байт младший
		
		data|=TWDR;
	}
		
	data = data>>5;

	_delay_ms(10);
	return (data);
}

/************************************************************************/
/* Запись одного байта в регистр                                        */
/************************************************************************/
void WRITE_ONE_BYTE_REG(uint8_t REG_CMD, uint8_t DATA)
{
	_delay_ms(10);

	I2C_COMAND(I2C_START);       // формируем сигнал START

	TWDR = WRITE_CMD;                 // Загружаем SLAVE-ADRESS
	I2C_COMAND(I2C_TRANSMIT);    // Передаем
	
	TWDR = REG_CMD;              // Загружаем адрес регистра который будем писать
	I2C_COMAND(I2C_TRANSMIT);    // Передаем
	
	TWDR = DATA;                 // Загружаем 8 бит данных в регистр
	I2C_COMAND(I2C_TRANSMIT);    // Передаем

	I2C_COMAND(I2C_STOP);        // Формируем сигнал STOP
	_delay_ms(10);
}

/************************************************************************/
/* Инициализация MAX6581                                                */
/************************************************************************/
uint8_t MAX6581_Init(void)
{
	uint8_t temp_data = 0;
	uint8_t diod_data = 0;
	I2C_INIT();
/************************************************************************/
/* КОНФИГУРАЦИЯ РЕГИСТРА ЗНАЧЕНИЕМ 0х00                                 */
/************************************************************************/
	WRITE_ONE_BYTE_REG(Conf_Reg,0x40);
	_delay_ms(100);
/************************************************************************/
/* КОНФИГУРАЦИЯ РЕГИСТРА ЗНАЧЕНИЕМ 0х02                                 */
/************************************************************************/
	WRITE_ONE_BYTE_REG(Conf_Reg,0x02);
	_delay_ms(100);
/************************************************************************/
/* ЧИТАЕМ РЕГИСТР НА ПРОВЕРКУ ЗАПИСИ                                    */
/************************************************************************/	
	temp_data = READ_ONE_BYTE_REG(Conf_Reg);
	_delay_ms(100);
/************************************************************************/
/*	Активация подстройки внешних транзисторов                           */
/************************************************************************/	
	WRITE_ONE_BYTE_REG(OFFSET_SELECT_REGISTER,0x7F);
	_delay_ms(100);
/************************************************************************/
/* СМЕЩЕНИЕ ТЕМПЕРАТУРЫ ВНЕШНИХ НА -1 ГРАДУС                            */
/************************************************************************/
	WRITE_ONE_BYTE_REG(OFFSET_T_REGISTER,0xFB);
	_delay_ms(100);
/************************************************************************/
/* ЧИТАЕМ DIOD FAULT РЕГИСТР                                            */
/************************************************************************/	
	diod_data = READ_ONE_BYTE_REG(0x46);
	_delay_ms(100);
/************************************************************************/
/* МАСКА OVERT                                                          */
/************************************************************************/	
	WRITE_ONE_BYTE_REG(0x43,0x00);
	_delay_ms(100);
/************************************************************************/
/* ПРОВЕРКА НАЛИЧИЯ ЧИПА - ПРОВЕРЯЕМ СЧИТАННЫЕ РЕГИСТРЫ                 */
/************************************************************************/
	if(temp_data==0x02 || diod_data) temp_data = 1;
	else temp_data = 0;
	return (temp_data);
}
/************************************************************************/
/* Чтение температуры с датчика                                         */
/************************************************************************/
float MAX6581_Read_Temp(uint8_t REG_CMD1, uint8_t REG_CMD2)
{
	uint16_t temp_word = 0;
	float real_temp = 0;
	
	temp_word = READ_TWO_BYTE_REG(REG_CMD1,REG_CMD2); // СЧИТЫВАЕМ ПОКАЗАТЕЛИ С ДАТЧИКА
	real_temp = ((float)(temp_word>>8) - 64) + (float)(temp_word&0x07)/8;
	//real_temp = (float)((temp_word>>5)*0.125f-64);
	//real_temp = (temp_word>>5)*0.125f;
	return real_temp;
}
